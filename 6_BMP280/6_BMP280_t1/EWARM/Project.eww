<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\6_BMP280_t1.ewp</path>
  </project>
  <batchBuild />
</workspace>
